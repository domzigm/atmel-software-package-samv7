# IAR project example.ewp, settings and files
configuration %configuration% (ARM, debug)
  General.OGChipSelectEditMenu: AT%chip% Atmel %chip%
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: %board%; __%chip%__; %configuration%
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ../../; %root_dir_i%libraries; %root_dir_i%libraries/libboard; %root_dir_i%libraries/libboard/include; %root_dir_i%libraries/libchip; %root_dir_i%libraries/libchip/include; %root_dir_i%libraries/libchip/include/%samv7%; %root_dir_i%libraries/libchip/include/cmsis/CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: %board%; __%chip%__; %configuration%; __ASSEMBLY__
  OBJCOPY.OOCOutputFile: %configuration%.bin
  ILINK.IlinkOutputFile: %configuration%.out
  ILINK.IlinkIcfFile: %%configuration%_icf%
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../: main.c
  group documentation
    $EW_DIR$/arm/examples/Atmel/: flashloaders.html
    %root_dir_c%documentation/html/: %example_name%.html
  group libraries/libboard
    %root_dir_c%libraries/libboard/: board.h
    %root_dir_c%libraries/libboard/source/: board_lowlevel.c board_memories.c dbg_console.c led.c trace.c
    %root_dir_c%libraries/libboard/%resources%/: system_sam.c
  group libraries/libchip
    %root_dir_c%libraries/libchip/: chip.h
    %root_dir_c%libraries/libchip/source/: exceptions.c mpu.c pio.c pio_it.c pmc.c supc.c tc.c timetick.c uart.c wdt.c xdma_hardware_interface.c xdmac.c xdmad.c
    %root_dir_c%libraries/libboard/%resources%/iar/: startup_sam.c
