# Keil uVision project example.uvprojx, settings and files
target %configuration% (ARM-ADS)
  device: AT%chip% Atmel
  pack: Keil.SAM-V_DFP.1.0.0
  cpu: IROM(0x00400000,0x00200000) IRAM(0x20400000,0x00060000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: %example_name%
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: %board% __%chip%__ %configuration%%predefine%
  c include: ..\..\;%root_dir_i%libraries\libchip;%root_dir_i%libraries\libchip\include;%root_dir_i%libraries\libchip\include\%samv7%;%root_dir_i%libraries\libchip\include\cmsis\CMSIS\Include;%root_dir_i%libraries\libboard;%root_dir_i%libraries\libboard\include%extra_include%
  memory RVCT4: ROM 0x400000 size 0x200000
  memory RVCT9: RAM 0x20400000 size 0x60000
  scatter file: %%configuration%_icf%
  link misc: --diag_suppress=L6314
  group application
    %root_dir_c%libraries/libboard/%resources%/mdk/: workaround.s
    ../../: main.c
  group libchip
    %root_dir_c%libraries/libchip/source/: exceptions.c mpu.c pio.c pio_it.c pmc.c supc.c tc.c timetick.c uart.c wdt.c xdma_hardware_interface.c xdmac.c xdmad.c
    %root_dir_c%libraries/libboard/%resources%/mdk/: retarget.c startup_sam.c
    %root_dir_c%libraries/libboard/%resources%/: system_sam.c
  group libboard
    %root_dir_c%libraries/libboard/source/: board_lowlevel.c board_memories.c dbg_console.c led.c trace.c
