# IAR project flashload_qspi.ewp, settings and files
configuration sram (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMV71Q21 Atmel ATSAMV71Q21
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAMV71Q21__; sram; TRACE_LEVEL=4
  ICCARM.CCIncludePath2: ../../../../libraries; ../../../../libraries/libboard_samv7-ek; ../../../../libraries/libboard_samv7-ek/include; ../../../../libraries/libchip_samv7; ../../../../libraries/libchip_samv7/include; ../../../../libraries/libchip_samv7/include/samv7; ../../../../libraries/libchip_samv7/include/cmsis/CMSIS/Include; ../../../../libraries/benchmark/dhrystone
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM4S16C__; sram; __ASSEMBLY__
  OBJCOPY.OOCOutputFile: sram.bin
  ILINK.IlinkOutputFile: sram.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Atmel\samv71q21\sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flash (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: __SAMV71Q21__; flash; TRACE_LEVEL=4
  AARM.ADefines: __SAM4S16C__; flash; __ASSEMBLY__
  AARM.AUserIncludes: ..\..\..\libraries
  OBJCOPY.OOCOutputFile: flashload_qspi.bin
  ILINK.IlinkOutputFile: flash.out
  ILINK.IlinkIcfFile: C:\softpack\canopus23\softpack\samv7\libraries\libboard_samv7-ek\resources\iar\flash_qspi.icf
  group (top)
    ../../: main.c
  group dhrystone
    ../../../../libraries/benchmark/dhrystone/: dhry.h dhry_1.c dhry_2.c
  group documentation
    ../../../../documentation/html/: flashload_qspi.html
    $EW_DIR$/arm/examples/Atmel/: flashloaders.html
  group libraries/libboard
    ../../../../libraries/libboard_samv7-ek/: board.h
    ../../../../libraries/libboard_samv7-ek/source/: board_lowlevel.c board_memories.c dbg_console.c led.c s25fl1.c trace.c
    ../../../../libraries/libboard_samv7-ek/resources/: system_sam.c
  group libraries/libchip
    ../../../../libraries/libchip_samv7/: chip.h
    ../../../../libraries/libchip_samv7/source/: exceptions.c mpu.c pio.c pio_it.c pmc.c qspi.c qspi_dma.c rtt.c supc.c tc.c timetick.c uart.c wdt.c xdma_hardware_interface.c xdmac.c xdmad.c
    ../../../../libraries/libboard_samv7-ek/resources/iar/: startup_sam.c
  group resources
    ../../../../libraries/libboard_samv7-ek/resources/iar/: samv71q21_flash.icf samv71q21_sram.icf
