<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\rtc.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>flash</name>
      <member>
        <project>rtc</project>
        <configuration>flash</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>sram</name>
      <member>
        <project>rtc</project>
        <configuration>sram</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>rtc</project>
        <configuration>sram</configuration>
      </member>
      <member>
        <project>rtc</project>
        <configuration>flash</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


