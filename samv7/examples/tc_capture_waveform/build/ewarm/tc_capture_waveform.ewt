<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>sram</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>flash</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>documentation</name>
    <file>
      <name>$EW_DIR$\arm\examples\Atmel\flashloaders.html</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\documentation\html\tc_capture_waveform.html</name>
    </file>
  </group>
  <group>
    <name>libraries</name>
    <group>
      <name>libboard</name>
      <group>
        <name>exclude</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\libboard_samv7-ek\source\at25_spi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\libboard_samv7-ek\source\at25d.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\libboard_samv7-ek\source\hamming.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\libboard_samv7-ek\source\math.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\libboard_samv7-ek\source\omnivision.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\libboard_samv7-ek\source\ov.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\libboard_samv7-ek\source\ov2640_config.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\libboard_samv7-ek\source\ov2643_config.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\libboard_samv7-ek\source\ov5640_config.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\libboard_samv7-ek\source\ov7740_config.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\libboard_samv7-ek\source\ov9740_config.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\libboard_samv7-ek\source\syscalls.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libboard_samv7-ek\board.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libboard_samv7-ek\source\board_lowlevel.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libboard_samv7-ek\source\board_memories.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libboard_samv7-ek\source\CS2100.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libboard_samv7-ek\source\dbg_console.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libboard_samv7-ek\source\gmacb.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libboard_samv7-ek\source\gmacd.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libboard_samv7-ek\source\ili9488.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libboard_samv7-ek\source\lcd_draw.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libboard_samv7-ek\source\lcd_font.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libboard_samv7-ek\source\lcd_font10x14.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libboard_samv7-ek\source\lcdd.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libboard_samv7-ek\source\led.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libboard_samv7-ek\resources\system_sam.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libboard_samv7-ek\source\trace.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libboard_samv7-ek\source\wav.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libboard_samv7-ek\source\wm8904.c</name>
      </file>
    </group>
    <group>
      <name>libchip</name>
      <group>
        <name>exclude</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\acc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\aes.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\afec.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\can.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\dacc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\efc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\flashd.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\icm.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\isi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\mediaLB.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\qspi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\rstc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\rtc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\rtt.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\sdramc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\smc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\trng.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\USBD_HAL.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\USBDCallbacks_Initialized.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\USBDCallbacks_Resumed.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\USBDCallbacks_Suspended.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\chip.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\exceptions.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\gmac.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\hsmci.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\mcid_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\mpu.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\pio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\pio_capture.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\pio_it.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\pmc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\pwmc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\spi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\spi_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\ssc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libboard_samv7-ek\resources\iar\startup_sam.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\supc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\tc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\timetick.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\twi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\twid.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\uart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\uart_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\usart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\usart_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\wdt.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\xdma_hardware_interface.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\xdmac.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\xdmad.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>resources</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\libraries\libboard_samv7-ek\resources\iar\samv71q21_flash.icf</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\libraries\libboard_samv7-ek\resources\iar\samv71q21_sram.icf</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\..\..\main.c</name>
  </file>
</project>


