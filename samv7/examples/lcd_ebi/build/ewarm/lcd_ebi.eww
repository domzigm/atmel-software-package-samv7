<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\lcd_ebi.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>flash</name>
      <member>
        <project>lcd_ebi</project>
        <configuration>flash</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>sram</name>
      <member>
        <project>lcd_ebi</project>
        <configuration>sram</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>lcd_ebi</project>
        <configuration>sram</configuration>
      </member>
      <member>
        <project>lcd_ebi</project>
        <configuration>flash</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


