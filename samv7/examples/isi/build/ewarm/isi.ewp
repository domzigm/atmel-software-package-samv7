# IAR project isi.ewp, settings and files
configuration sram (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMV71Q21 Atmel SAMV71Q21
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD_SAMV71_XULT; __SAMV71Q21__; sram; MCK_123MHZ; TRACE_LEVEL=4
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ../../; ../../../../libraries; ../../../../libraries/libboard; ../../../../libraries/libboard/include; ../../../../libraries/libchip; ../../../../libraries/libchip/include; ../../../../libraries/libchip/include/samv71; ../../../../libraries/libchip/include/cmsis/CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD_SAMV71_XULT; __SAMV71Q21__; sram; __ASSEMBLY__
  OBJCOPY.OOCOutputFile: sram.bin
  ILINK.IlinkOutputFile: sram.out
  ILINK.IlinkIcfFile: ..\..\..\..\libraries\libboard\resources_v71\iar\samv71q21_sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flash (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMV71_XULT; __SAMV71Q21__; flash; MCK_123MHZ; TRACE_LEVEL=4
  AARM.ADefines: BOARD_SAMV71_XULT; __SAMV71Q21__; flash; __ASSEMBLY__
  OBJCOPY.OOCOutputFile: flash.bin
  ILINK.IlinkOutputFile: flash.out
  ILINK.IlinkIcfFile: ..\..\..\..\libraries\libboard\resources_v71\iar\samv71q21_flash.icf
  group (top)
    ../../: main.c
  group documentation
    $EW_DIR$/arm/examples/Atmel/: flashloaders.html
    ../../../../documentation/html/: isi.html
  group libraries/libboard
    ../../../../libraries/libboard/source/: image_sensor_inf.c ov2640_config.c ov2643_config.c ov5640_config.c ov7740_config.c ov9740_config.c lcd_draw.c lcd_font.c lcd_fontsize.c lcdd.c ili9488_ebi.c ili9488_spi.c ili9488_spi_dma.c ili9488_ebi_dma.c board_lowlevel.c board_memories.c dbg_console.c led.c trace.c
    ../../../../libraries/libboard/: board.h
    ../../../../libraries/libboard/resources_v71/: system_samv71.c
  group libraries/libchip
    ../../../../libraries/libchip/source/: spi.c spi_dma.c pwmc.c isi.c twi.c twid.c exceptions.c mpu.c pio.c pio_it.c pmc.c supc.c tc.c timetick.c uart.c wdt.c xdma_hardware_interface.c xdmac.c xdmad.c
    ../../../../libraries/libchip/: chip.h
    ../../../../libraries/libboard/resources_v71/iar/: startup_samv71.c
  group resources
    ../../../../libraries/libboard/resources_v71/iar/: samv71q21_sram.icf samv71q21_flash.icf
