# IAR project fft_demo.ewp, settings and files
configuration flash (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMV71Q21 Atmel SAMV71Q21
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD_SAMV71_XULT; __SAMV71Q21__; flash; ENABLE_TCM; FFT_DEMO; TRACE_LEVEL=4
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ../../; ../../../../libraries; ../../../../libraries/libboard; ../../../../libraries/libboard/include; ../../../../libraries/libchip; ../../../../libraries/libchip/include; ../../../../libraries/libchip/include/samv71; ../../../../libraries/libchip/include/cmsis/CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD_SAMV71_XULT; __SAMV71Q21__; flash; __ASSEMBLY__
  OBJCOPY.OOCOutputFile: flash.bin
  ILINK.IlinkOutputFile: flash.out
  ILINK.IlinkIcfFile: config\flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\libraries\libchip\include\cmsis\CMSIS\Lib\ARM\arm_cortexM7lfdp_math.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration app (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMV71_XULT; __SAMV71Q21__; app; ENABLE_TCM; FFT_DEMO; TRACE_LEVEL=4
  AARM.ADefines: BOARD_SAMV71_XULT; __SAMV71Q21__; app; __ASSEMBLY__
  OBJCOPY.OOCOutputFile: app.bin
  ILINK.IlinkOutputFile: app.out
  ILINK.IlinkIcfFile: config\app.icf
  group (top)
    ../../: main.c arm_math.h fft.c fft.h math.h signal.c signal.h sound.h
  group documentation
    $EW_DIR$/arm/examples/Atmel/: flashloaders.html
    ../../../../documentation/html/: fft_demo.html
  group libraries/libboard
    ../../../../libraries/libboard/source/: lcd_draw.c lcd_font.c lcd_fontsize.c lcdd.c ili9488_ebi.c ili9488_ebi_dma.c ili9488_spi.c ili9488_spi_dma.c board_lowlevel.c board_memories.c dbg_console.c led.c trace.c
    ../../../../libraries/libboard/: board.h
    ../../../../libraries/libboard/resources_v71/: system_samv71.c
  group libraries/libchip
    ../../../../libraries/libchip/source/: spi.c spi_dma.c pwmc.c trng.c exceptions.c mpu.c pio.c pio_it.c pmc.c supc.c tc.c timetick.c uart.c wdt.c xdma_hardware_interface.c xdmac.c xdmad.c
    ../../../../libraries/libchip/include/cmsis/CMSIS/Lib/ARM/: arm_cortexM7lfdp_math.lib
    ../../../../libraries/libchip/: chip.h
    ../../../../libraries/libboard/resources_v71/iar/: startup_samv71.c
  group resources
    config/: flash.icf app.icf
