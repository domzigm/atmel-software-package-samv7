# Keil uVision project fft_demo.uvprojx, settings and files
target flash (ARM-ADS)
  device: ATSAMV71Q21 Atmel
  pack: Keil.SAM-V_DFP.1.0.0
  cpu: IROM(0x00400000,0x00200000) IRAM(0x20400000,0x00060000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: fft_demo
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: BOARD_SAMV71_XULT __SAMV71Q21__ flash ENABLE_TCM FFT_DEMO TRACE_LEVEL=4
  c include: ..\..\;..\..\..\..\libraries\libchip;..\..\..\..\libraries\libchip\include;..\..\..\..\libraries\libchip\include\samv71;..\..\..\..\libraries\libchip\include\cmsis\CMSIS\Include;..\..\..\..\libraries\libboard;..\..\..\..\libraries\libboard\include
  memory RVCT4: ROM 0x400000 size 0x200000
  memory RVCT9: RAM 0x20400000 size 0x60000
  scatter file: .\flash.sct
  group application
    ../../../../libraries/libboard/resources_v71/mdk/: workaround.s
    ../../: main.c fft.c signal.c
  group libchip
    ../../../../libraries/libchip/source/: exceptions.c mpu.c pio.c pio_it.c pmc.c supc.c tc.c timetick.c uart.c wdt.c xdma_hardware_interface.c xdmac.c xdmad.c spi.c spi_dma.c pwmc.c trng.c
    ../../../../libraries/libboard/resources_v71/mdk/: retarget.c startup_sam.c
    ../../../../libraries/libboard/resources_v71/: system_samv71.c
    ../../../../libraries/libchip/include/cmsis/CMSIS/Lib/ARM/: arm_cortexM7lfdp_math.lib
  group libboard
    ../../../../libraries/libboard/source/: board_lowlevel.c board_memories.c dbg_console.c led.c trace.c lcd_draw.c lcd_font.c lcd_fontsize.c lcdd.c ili9488_ebi.c ili9488_ebi_dma.c ili9488_spi.c ili9488_spi_dma.c
target app (ARM-ADS)
  device: ATSAMV71Q21 Atmel
  pack: Keil.SAM-V_DFP.1.0.0
  cpu: as above
  output: fft_demo
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: BOARD_SAMV71_XULT __SAMV71Q21__ app ENABLE_TCM FFT_DEMO TRACE_LEVEL=4
  c include: as above
  memory RVCT4: ROM 0x400000 size 0x200000
  memory RVCT9: RAM 0x20400000 size 0x60000
  scatter file: .\app.sct
