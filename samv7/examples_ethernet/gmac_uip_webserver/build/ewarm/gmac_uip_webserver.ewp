# IAR project gmac_uip_webserver.ewp, settings and files
configuration sram (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMV71Q21 Atmel SAMV71Q21
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD_SAMV71_XULT; __SAMV71Q21__; sram; MPU_HAS_NOCACHE_REGION; TRACE_LEVEL=4
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ../../; ../../../../libraries; ../../../../libraries/libboard; ../../../../libraries/libboard/include; ../../../../libraries/libchip; ../../../../libraries/libchip/include; ../../../../libraries/libchip/include/samv71; ../../../../libraries/libchip/include/cmsis/CMSIS/Include; ../../../../libraries/libuip/source/samv7-specific; ../../../../libraries/libuip/source/uip_1.0; ../../../../libraries/libuip/source/uip_1.0/apps/dhcpc; ../../../../libraries/libuip/source/uip_1.0/lib; ../../../../libraries/libuip/source/uip_1.0/uip; ../../../../libraries/libuip/source/uip_1.0/apps/webserver
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD_SAMV71_XULT; __SAMV71Q21__; sram; __ASSEMBLY__
  OBJCOPY.OOCOutputFile: sram.bin
  ILINK.IlinkOutputFile: sram.out
  ILINK.IlinkIcfFile: ..\..\..\..\libraries\libboard\resources_v71\nocache_region\iar\samv71q21_sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flash (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMV71_XULT; __SAMV71Q21__; flash; MPU_HAS_NOCACHE_REGION; TRACE_LEVEL=4
  AARM.ADefines: BOARD_SAMV71_XULT; __SAMV71Q21__; flash; __ASSEMBLY__
  OBJCOPY.OOCOutputFile: flash.bin
  ILINK.IlinkOutputFile: flash.out
  ILINK.IlinkIcfFile: ..\..\..\..\libraries\libboard\resources_v71\nocache_region\iar\samv71q21_flash.icf
  group (top)
    ../../: main.c uip-conf.h
  group documentation
    $EW_DIR$/arm/examples/Atmel/: flashloaders.html
    ../../../../documentation/html/: gmac_uip_webserver.html
  group libraries/libboard
    ../../../../libraries/libboard/source/: gmacb_phy.c board_lowlevel.c board_memories.c dbg_console.c led.c trace.c
    ../../../../libraries/libboard/: board.h
    ../../../../libraries/libboard/resources_v71/: system_samv71.c
  group libraries/libchip
    ../../../../libraries/libchip/source/: gmac.c gmacd.c twi.c twid.c exceptions.c mpu.c pio.c pio_it.c pmc.c supc.c tc.c timetick.c uart.c wdt.c xdma_hardware_interface.c xdmac.c xdmad.c
    ../../../../libraries/libchip/: chip.h
    ../../../../libraries/libboard/resources_v71/iar/: startup_samv71.c
  group libraries/libuip
    ../../../../libraries/libuip/source/uip_1.0/apps/webserver/: httpd.c httpd-cgi.c httpd-fs.c http-strings.c
    ../../../../libraries/libuip/source/uip_1.0/lib/: memb.c memb.h
    ../../../../libraries/libuip/source/samv7-specific/: clock-arch.c clock-arch.h gmac_tapdev.c gmac_tapdev.h
    ../../../../libraries/libuip/source/uip_1.0/uip/: clock.h lc-addrlabels.h lc-switch.h lc.h psock.c psock.h pt.h timer.c timer.h uip-fw.c uip-fw.h uip.c uip.h uip_arch.h uip_arp.c uip_arp.h uiplib.c uiplib.h uipopt.h
  group resources
    ../../../../libraries/libboard/resources_v71/nocache_region/iar/: samv71q21_sram.icf samv71q21_flash.icf
