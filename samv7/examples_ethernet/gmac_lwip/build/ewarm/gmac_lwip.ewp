# IAR project gmac_lwip.ewp, settings and files
configuration sram (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMV71Q21 Atmel SAMV71Q21
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD_SAMV71_XULT; __SAMV71Q21__; sram; MPU_HAS_NOCACHE_REGION; TRACE_LEVEL=4
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ../../; ../../../../libraries; ../../../../libraries/libboard; ../../../../libraries/libboard/include; ../../../../libraries/libchip; ../../../../libraries/libchip/include; ../../../../libraries/libchip/include/samv71; ../../../../libraries/libchip/include/cmsis/CMSIS/Include; ../../../../libraries/liblwip/source/lwip_1.3.2/src/include; ../../../../libraries/liblwip/source/lwip_1.3.2/src/include/lwip; ../../../../libraries/liblwip/source/lwip_1.3.2/src/include/ipv4; ../../../../libraries/liblwip/source/lwip_1.3.2/src/include/netif; ../../../../libraries/liblwip/source/samv7-specific; ../../../../libraries/liblwip
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD_SAMV71_XULT; __SAMV71Q21__; sram; __ASSEMBLY__
  OBJCOPY.OOCOutputFile: sram.bin
  ILINK.IlinkOutputFile: sram.out
  ILINK.IlinkIcfFile: ..\..\..\..\libraries\libboard\resources_v71\nocache_region\iar\samv71q21_sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flash (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMV71_XULT; __SAMV71Q21__; flash; MPU_HAS_NOCACHE_REGION; TRACE_LEVEL=4
  AARM.ADefines: BOARD_SAMV71_XULT; __SAMV71Q21__; flash; __ASSEMBLY__
  OBJCOPY.OOCOutputFile: flash.bin
  ILINK.IlinkOutputFile: flash.out
  ILINK.IlinkIcfFile: ..\..\..\..\libraries\libboard\resources_v71\nocache_region\iar\samv71q21_flash.icf
  group (top)
    ../../: main.c httpd.c httpd.h
  group documentation
    $EW_DIR$/arm/examples/Atmel/: flashloaders.html
    ../../../../documentation/html/: gmac_lwip.html
  group libraries/libboard
    ../../../../libraries/libboard/source/: gmacb_phy.c board_lowlevel.c board_memories.c dbg_console.c led.c trace.c
    ../../../../libraries/libboard/: board.h
    ../../../../libraries/libboard/resources_v71/: system_samv71.c
  group libraries/libchip
    ../../../../libraries/libchip/source/: gmac.c gmacd.c twi.c twid.c exceptions.c mpu.c pio.c pio_it.c pmc.c supc.c tc.c timetick.c uart.c wdt.c xdma_hardware_interface.c xdmac.c xdmad.c
    ../../../../libraries/libchip/: chip.h
    ../../../../libraries/libboard/resources_v71/iar/: startup_samv71.c
  group libraries/liblwip
    ../../../../libraries/liblwip/source/lwip_1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../libraries/liblwip/source/lwip_1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../../libraries/liblwip/source/lwip_1.3.2/src/core/snmp/: asn1_dec.c asn1_enc.c mib2.c mib_structs.c msg_in.c msg_out.c
    ../../../../libraries/liblwip/source/lwip_1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../../../../libraries/liblwip/source/lwip_1.3.2/src/netif/: etharp.c ethernetif.c loopif.c slipif.c
    ../../../../libraries/liblwip/source/samv7-specific/: gmacif.c
    ../../../../libraries/liblwip/source/samv7-specific/arch/: sys_arch.c
    ../../../../libraries/liblwip/: liblwip.h
  group resources
    ../../../../libraries/libboard/resources_v71/nocache_region/iar/: samv71q21_sram.icf samv71q21_flash.icf
