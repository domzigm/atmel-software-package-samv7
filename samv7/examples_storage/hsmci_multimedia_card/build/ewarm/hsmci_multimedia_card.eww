<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\hsmci_multimedia_card.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>flash</name>
      <member>
        <project>hsmci_multimedia_card</project>
        <configuration>flash</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>sram</name>
      <member>
        <project>hsmci_multimedia_card</project>
        <configuration>sram</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>hsmci_multimedia_card</project>
        <configuration>sram</configuration>
      </member>
      <member>
        <project>hsmci_multimedia_card</project>
        <configuration>flash</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


