<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>sram</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>flash</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>documentation</name>
    <file>
      <name>$EW_DIR$\arm\examples\Atmel\flashloaders.html</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\documentation\html\hsmci_sdcard.html</name>
    </file>
  </group>
  <group>
    <name>libraries</name>
    <group>
      <name>libboard</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libboard_samv7-ek\board.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libboard_samv7-ek\source\board_lowlevel.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libboard_samv7-ek\source\board_memories.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libboard_samv7-ek\source\dbg_console.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libboard_samv7-ek\source\led.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libboard_samv7-ek\source\s25fl1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libboard_samv7-ek\resources\system_sam.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libboard_samv7-ek\source\trace.c</name>
      </file>
    </group>
    <group>
      <name>libchip</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\chip.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\exceptions.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\hsmci.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\hsmcid.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\mpu.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\pio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\pio_it.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\pmc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\qspi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libboard_samv7-ek\resources\iar\startup_sam.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\supc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\tc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\timetick.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\uart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\wdt.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\xdma_hardware_interface.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\xdmac.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libchip_samv7\source\xdmad.c</name>
      </file>
    </group>
    <group>
      <name>libfatfs</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libfatfs\src\option\ccsbcs.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libfatfs\src\diskio_samv7x.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libfatfs\fatfs_config.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libfatfs\src\ff.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libfatfs\src\lowlevel.c</name>
      </file>
    </group>
    <group>
      <name>libmemory</name>
      <group>
        <name>sdmmc</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\libstoragemedia\source\sdmmc\sdmmc.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libstoragemedia\source\Media.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\libstoragemedia\source\MEDSdcard.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>resources</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\libraries\libboard_samv7-ek\resources\iar\samv71q21_flash.icf</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\libraries\libboard_samv7-ek\resources\iar\samv71q21_sram.icf</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\..\..\main.c</name>
  </file>
</project>


