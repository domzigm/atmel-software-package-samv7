# IAR project whetstone.ewp, settings and files
configuration sram (ARM, debug)
  General.OGChipSelectEditMenu: SAMA5D35 Atmel SAMA5D35
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: sama5d3x; sram; TRACE_LEVEL=4
  ICCARM.CCIncludePath2: ../../../../libraries; ../../../../libraries/libboard_sama5d3x-ek; ../../../../libraries/libchip_sama5d3x
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.ADefines: sama5d3x; sram; __ASSEMBLY__
  OBJCOPY.OOCOutputFile: sram.bin
  ILINK.IlinkOutputFile: sram.out
  ILINK.IlinkIcfFile: ../../../../libraries/libboard_sama5d3x-ek/resources/ewarm/sama5d3x/sram.icf
  ILINK.IlinkProgramEntryLabel: resetHandler
configuration ddram (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: sama5d3x; ddram; TRACE_LEVEL=4
  AARM.ADefines: sama5d3x; ddram; __ASSEMBLY__
  AARM.AUserIncludes: ..\..\..\libraries
  OBJCOPY.OOCOutputFile: ddram.bin
  ILINK.IlinkOutputFile: ddram.out
  ILINK.IlinkIcfFile: ../../../../libraries/libboard_sama5d3x-ek/resources/ewarm/sama5d3x/ddram.icf
  group (top)
    ../../: main.c
  group documentation
    $EW_DIR$/arm/examples/Atmel/: flashloaders.html
    $EW_DIR$/arm/examples/Atmel/sama5d3x-ek/documentation/html/: whetstone.html
  group libraries
    ../../../../libraries/libboard_sama5d3x-ek/lib/: libboard_sama5d3x_ek_ewarm_dbg.a
    ../../../../libraries/libchip_sama5d3x/lib/: libchip_sama5d3x_ewarm_dbg.a
  group resources
    ../../../../libraries/libboard_sama5d3x-ek/resources/ewarm/sama5d3x/: ddram.icf sram.icf
