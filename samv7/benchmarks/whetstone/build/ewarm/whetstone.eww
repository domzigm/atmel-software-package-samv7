<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\whetstone.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\..\libraries\libboard_sama5d3x-ek\build\ewarm\libboard_sama5d3x.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\..\libraries\libchip_sama5d3x\build\ewarm\libchip_sama5d3x.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ddram</name>
      <member>
        <project>libchip_sama5d3x</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libboard_sama5d3x</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>whetstone</project>
        <configuration>ddram</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>sram</name>
      <member>
        <project>libchip_sama5d3x</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libboard_sama5d3x</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>whetstone</project>
        <configuration>sram</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>libchip_sama5d3x</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libchip_sama5d3x</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libboard_sama5d3x</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libboard_sama5d3x</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>whetstone</project>
        <configuration>sram</configuration>
      </member>
      <member>
        <project>whetstone</project>
        <configuration>ddram</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


