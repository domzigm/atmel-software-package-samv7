# IAR project dhrystone.ewp, settings and files
configuration sram (ARM, debug)
  General.OGChipSelectEditMenu: SAMV71Q21 Atmel SAMV71Q21
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAMV71Q21__; sram; ENABLE_TCM; TRACE_LEVEL=4; __ICACHE_PRESENT; __DCACHE_PRESENT
  ICCARM.CCIncludePath2: ../../../../libraries; ../../../../libraries/libboard_samv7-ek; ../../../../libraries/libboard_samv7-ek/include; ../../../../libraries/libchip_samv7; ../../../../libraries/libchip_samv7/include; ../../../../libraries/libchip_samv7/include/samv7; ../../../../libraries/libchip_samv7/include/cmsis/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM4S16C__; sram; __ASSEMBLY__
  OBJCOPY.OOCOutputFile: sram.bin
  ILINK.IlinkOutputFile: sram.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Atmel\samv71q21\sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flash (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: __SAMV71Q21__; flash; ENABLE_TCM; TRACE_LEVEL=4; __ICACHE_PRESENT; __DCACHE_PRESENT
  AARM.ADefines: __SAM4S16C__; flash; __ASSEMBLY__
  AARM.AUserIncludes: ..\..\..\libraries
  OBJCOPY.OOCOutputFile: flash.bin
  ILINK.IlinkOutputFile: flash.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Atmel\samv71q21\flash.icf
  group (top)
    ../../: dhry.h dhry_1.c dhry_2.c main.c
  group documentation
    ../../../../documentation/html/: dhrystone.html
    $EW_DIR$/arm/examples/Atmel/: flashloaders.html
  group libraries/libboard
    ../../../../libraries/libboard_samv7-ek/: board.h
    ../../../../libraries/libboard_samv7-ek/source/: board_lowlevel.c board_memories.c cs2100.c dbg_console.c ili9488.c led.c trace.c wav.c wm8904.c
    ../../../../libraries/libboard_samv7-ek/resources/: system_sam.c
  group libraries/libchip
    ../../../../libraries/libchip_samv7/: chip.h
    ../../../../libraries/libchip_samv7/source/: efc.c exceptions.c flashd.c mpu.c pio.c pio_capture.c pio_it.c pmc.c pwmc.c rtt.c spi.c spi_dma.c ssc.c supc.c tc.c timetick.c trng.c twi.c twid.c uart.c uart_dma.c usart.c usart_dma.c wdt.c xdma_hardware_interface.c xdmac.c xdmad.c
    ../../../../libraries/libboard_samv7-ek/resources/iar/: startup_sam.c
  group resources
    ../../../../libraries/libboard_samv7-ek/resources/iar/: samv71q21_flash.icf samv71q21_sram.icf
