# IAR project qspi_flash.ewp, settings and files
configuration sram (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMV71Q21 Atmel SAMV71Q21
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAMV71Q21__; sram; TRACE_LEVEL=4
  ICCARM.CCIncludePath2: ../../../../libraries; ../../../../libraries/libboard_samv7-ek; ../../../../libraries/libboard_samv7-ek/include; ../../../../libraries/libchip_samv7; ../../../../libraries/libchip_samv7/include; ../../../../libraries/libchip_samv7/include/samv7; ../../../../libraries/libchip_samv7/include/cmsis/CMSIS/Include; ../../../../libraries/libfatfs/inc; ../../../../libraries/libfatfs/src; ../../../../libraries/libfatfs; ../../../../libraries/libstoragemedia/include/sdmmc; ../../../../libraries/libstoragemedia/include; ../../../../libraries/libstoragemedia
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM4S16C__; sram; __ASSEMBLY__
  OBJCOPY.OOCOutputFile: sram.bin
  ILINK.IlinkOutputFile: sram.out
  ILINK.IlinkIcfFile: ../../../../libraries/libboard_samv7-ek/resources/iar/samv71q21_sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flash (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: __SAM4S16C__; flash; TRACE_LEVEL=4
  ICCARM.CCIncludePath2: ../../../../libraries; ../../../../libraries/libboard_sam4s-ek; ../../../../libraries/libchip_sam4s
  ICCARM.CCOptLevel: 3
  AARM.ADefines: __SAM4S16C__; flash; __ASSEMBLY__
  AARM.AUserIncludes: ..\..\..\libraries
  OBJCOPY.OOCOutputFile: flash.bin
  ILINK.IlinkOutputFile: flash.out
  ILINK.IlinkIcfFile: ../../../../libraries/libboard_sam4s-ek/resources/ewarm/sam4s16/flash.icf
  group (top)
    ../../: main.c
  group documentation
    $EW_DIR$/arm/examples/Atmel/: flashloaders.html
    ../../../../documentation/html/: qspi_flash.html
  group libraries/libboard
    ../../../../libraries/libboard_samv7-ek/: board.h
    ../../../../libraries/libboard_samv7-ek/source/: board_lowlevel.c board_memories.c cs2100.c dbg_console.c gmacb_phy.c ili9488.c lcd_draw.c lcd_font.c lcd_font10x14.c lcdd.c led.c s25fl1.c trace.c wav.c wm8904.c
    ../../../../libraries/libboard_samv7-ek/resources/: system_sam.c
  group libraries/libboard/exclude
    ../../../../libraries/libboard_samv7-ek/source/: at25_spi.c at25d.c hamming.c math.c omnivision.c ov.c ov2640_config.c ov2643_config.c ov5640_config.c ov7740_config.c ov9740_config.c s25fl1_qspi.c syscalls.c
  group libraries/libchip
    ../../../../libraries/libchip_samv7/: chip.h
    ../../../../libraries/libchip_samv7/source/: efc.c exceptions.c flashd.c gmac.c gmacd.c hsmci.c isi.c mcid_dma.c mpu.c pio.c pio_capture.c pio_it.c pmc.c qspi.c qspi_dma.c spi.c spi_dma.c ssc.c supc.c tc.c timetick.c twi.c twid.c uart.c uart_dma.c usart.c usart_dma.c wdt.c xdma_hardware_interface.c xdmac.c xdmad.c
    ../../../../libraries/libboard_samv7-ek/resources/iar/: startup_sam.c
  group libraries/libchip/exclude
    ../../../../libraries/libchip_samv7/source/: acc.c aes.c afec.c can.c dacc.c icm.c mediaLB.c pwmc.c rstc.c rtc.c rtt.c sdramc.c smc.c trng.c USBD_HAL.c USBDCallbacks_Initialized.c USBDCallbacks_Resumed.c USBDCallbacks_Suspended.c
  group libraries/libmemory
    ../../../../libraries/libstoragemedia/source/: Media.c
  group resources
    ../../../../libraries/libboard_samv7-ek/resources/iar/: samv71q21_flash.icf samv71q21_sram.icf
