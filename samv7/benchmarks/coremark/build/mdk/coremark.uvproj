# Keil uVision project coremark.uvproj, settings and files
target ddram_icache (ARM-ADS)
  device: at91sam9g25 Atmel
  output: ddram
  AfterMake: fromelf.exe --bin -o  "$L@L.bin" "#L"
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: sam9g25 ddram icache TRACE_LEVEL=4 ITERATIONS=2000
  c misc: --gnu
  c include: ..\..;..\..\..\..\libraries\libboard_sam9xx5-ek;..\..\..\..\libraries\libchip_sam9xx5;..\..\..\..\libraries\benchmark\coremark
  scatter file: ..\..\..\..\libraries\libboard_sam9xx5-ek\resources\mdk\sam9g25\ddram.sct
  link misc: --entry resetHandler
  group source
    ../../../../libraries/libboard_sam9xx5-ek/source/: board_cstartup_keil.s
    ../../: core_portme.c
    ../../../../libraries/benchmark/coremark/: core_list_join.c core_main.c core_matrix.c core_state.c core_util.c
  group libraries
    ../../../../libraries/libchip_sam9xx5/lib/: libchip_sam9g25_mdk_dbg.lib
    ../../../../libraries/libboard_sam9xx5-ek/lib/: libboard_sam9g25_ek_mdk_dbg.lib
target ddram (ARM-ADS)
  device: at91sam9g25 Atmel
  output: ddram
  AfterMake: fromelf.exe --bin -o  "$L@L.bin" "#L"
  c flags: Optim=3 oTime=1 OneElfS=1
  c define: sam9g25 ddram TRACE_LEVEL=4 ITERATIONS=800
  c misc: --gnu
  c include: as above
  scatter file: as above
  link misc: --entry resetHandler
target sram (ARM-ADS)
  device: AT91sam9g25 Atmel
  cpu: IRAM(0x300000-0x307FFF) IROM(0x400000-0x40FFFF) CLOCK(12000000) CPUTYPE(ARM926EJ-S)
  output: sram
  AfterMake: fromelf.exe --bin -o  "$L@L.bin" "#L"
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: sam9g25 sram  TRACE_LEVEL=4 ITERATIONS=2000
  c misc: --gnu
  c include: as above
  memory RVCT4: ROM 0x400000 size 0x10000
  memory RVCT9: RAM 0x300000 size 0x8000
  scatter file: ../../../../libraries/libboard_sam9xx5-ek/resources/mdk/sam9g25/sram.sct
  link misc: --entry resetHandler
