# IAR project coremark.ewp, settings and files
configuration sram (ARM, debug)
  General.OGChipSelectEditMenu: SAMV71Q21 Atmel SAMV71Q21
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAMV71Q21__; sram; TRACE_LEVEL=4; __ICACHE_PRESENT; __DCACHE_PRESENT; __TCM_PRESENT; __FPU_PRESENT; __MPU_PRESENT
  ICCARM.CCIncludePath2: ../../; ../../../../libraries; ../../../../libraries/libboard_samv7-ek; ../../../../libraries/libboard_samv7-ek/include; ../../../../libraries/libchip_samv7; ../../../../libraries/libchip_samv7/include; ../../../../libraries/libchip_samv7/include/samv7; ../../../../libraries/libchip_samv7/include/cmsis/CMSIS/Include; ../../../../libraries/benchmark/coremark
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM4S16C__; sram; __ASSEMBLY__
  OBJCOPY.OOCOutputFile: sram.bin
  ILINK.IlinkOutputFile: sram.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Atmel\samv71q21\sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flash (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: __SAMV71Q21__; flash; TRACE_LEVEL=4; __ICACHE_PRESENT; __DCACHE_PRESENT; __FPU_PRESENT; __MPU_PRESENT
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Atmel\samv71q21\flash.icf
  group (top)
    ../../: core_portme.c core_portme.h
  group documentation
    ../../../../documentation/html/: coremark.html
    $EW_DIR$/arm/examples/Atmel/: flashloaders.html
  group libraries/coremark
    ../../../../libraries/benchmark/coremark/: core_list_join.c core_main.c core_matrix.c core_state.c core_util.c
  group libraries/libboard
    ../../../../libraries/libboard_samv7-ek/: board.h
    ../../../../libraries/libboard_samv7-ek/source/: board_lowlevel.c board_memories.c dbg_console.c led.c trace.c
    ../../../../libraries/libboard_samv7-ek/resources/: system_sam.c
  group libraries/libboard/exclude
    ../../../../libraries/libboard_samv7-ek/source/: at25_spi.c at25d.c cs2100.c hamming.c ili9488.c lcd_draw.c lcd_font.c lcd_font10x14.c lcdd.c math.c omnivision.c ov.c ov2640_config.c ov2643_config.c ov5640_config.c ov7740_config.c ov9740_config.c syscalls.c wav.c wm8904.c
  group libraries/libchip
    ../../../../libraries/libchip_samv7/: chip.h
    ../../../../libraries/libchip_samv7/source/: exceptions.c mpu.c pio.c pio_it.c pmc.c rtt.c supc.c tc.c timetick.c uart.c usart.c wdt.c xdma_hardware_interface.c xdmac.c xdmad.c
    ../../../../libraries/libboard_samv7-ek/resources/iar/: startup_sam.c
  group libraries/libchip/exclude
    ../../../../libraries/libchip_samv7/source/: acc.c aes.c afec.c can.c dacc.c efc.c flashd.c hsmci.c icm.c isi.c mediaLB.c pio_capture.c pwmc.c qspi.c rstc.c rtc.c sdramc.c smc.c spi.c spi_dma.c spid.c ssc.c trng.c twi.c twid.c uart_dma.c usart_dma.c USBD_HAL.c USBDCallbacks_Initialized.c USBDCallbacks_Resumed.c USBDCallbacks_Suspended.c
  group resources
    ../../../../libraries/libboard_samv7-ek/resources/iar/: samv71q21_flash.icf samv71q21_sram.icf
