# IAR project qspiFlashLoader.ewp, settings and files
configuration SAME70q21 (ARM, debug)
  General.OGChipSelectEditMenu: ATSAME70Q21 Atmel ATSAME70Q21
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAME70Q21__; sram
  ICCARM.CCIncludePath2: $PROJ_DIR$; include; $TOOLKIT_DIR$\src\flashloader\framework2; $TOOLKIT_DIR$\inc\Atmel\SAME70; $TOOLKIT_DIR$\CMSIS\include; ..\interface
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: qspiFlashLoader.srec
  ILINK.IlinkOutputFile: SAME70q21-qspiflash.out
  ILINK.IlinkIcfFile: mapping\SAME70q21_sram_flashloader.icf
  ILINK.IlinkProgramEntryLabel: FlashInitEntry
configuration SAME70q20 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: ATSAME70Q20 Atmel ATSAME70Q20
  ICCARM.CCDefines: __SAME70Q20__; sram
  ICCARM.CCIncludePath2: $PROJ_DIR$; include; $TOOLKIT_DIR$\src\flashloader\framework2; $TOOLKIT_DIR$\inc\Atmel\SAME70; ..\interface; $TOOLKIT_DIR$\CMSIS\include
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: SAME70q20-flash.out
  ILINK.IlinkIcfFile: mapping\SAME70q20_sram_flashloader.icf
configuration SAME70q19 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: ATSAME70Q19 Atmel ATSAME70Q19
  ICCARM.CCDefines: __SAME70Q19__; sram
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: SAME70q19-flash.out
  ILINK.IlinkIcfFile: mapping\SAME70q19_sram_flashloader.icf
configuration SAME70n21 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: ATSAME70N21 Atmel ATSAME70N21
  ICCARM.CCDefines: __SAME70N21__; sram
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: SAME70n21-flash.out
  ILINK.IlinkIcfFile: mapping\SAME70n21_sram_flashloader.icf
configuration SAME70n20 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: ATSAME70N20 Atmel ATSAME70N20
  ICCARM.CCDefines: __SAME70N20__; sram
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: SAME70n20-flash.out
  ILINK.IlinkIcfFile: mapping\SAME70n20_sram_flashloader.icf
configuration SAME70n19 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: ATSAME70N19 Atmel ATSAME70N19
  ICCARM.CCDefines: __SAME70N19__; sram
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: SAME70n19-flash.out
  ILINK.IlinkIcfFile: mapping\SAME70n19_sram_flashloader.icf
configuration SAME70j21 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: ATSAME70J21 Atmel ATSAME70J21
  ICCARM.CCDefines: __SAME70J21__; sram
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: SAME70j21-flash.out
  ILINK.IlinkIcfFile: mapping\SAME70j21_sram_flashloader.icf
configuration SAME70j20 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: ATSAME70J20 Atmel ATSAME70J20
  ICCARM.CCDefines: __SAME70J20__; sram
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: SAME70j20-flash.out
  ILINK.IlinkIcfFile: mapping\SAME70j20_sram_flashloader.icf
configuration SAME70j19 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: ATSAME70J19 Atmel ATSAME70J19
  ICCARM.CCDefines: __SAME70J19__; sram
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: SAME70j19-flash.out
  ILINK.IlinkIcfFile: mapping\SAME70j19_sram_flashloader.icf
  group (top)
    include/: board.h pio.h pmc.h qspi.h qspi_dma.h s25fl1.h xdmac.h xdmad.h
    ./: flash_config.h qspiFlashLoader.c
    ../interface/: Interface.c
    src/: pio.c pmc.c qspi.c s25fl1.c
  group framework
    $EW_DIR$/arm/src/flashloader/framework2/: flash_loader.c flash_loader_asm.s
  group mapping
    mapping/: SAME70j19_sram_flashloader.icf SAME70j20_sram_flashloader.icf SAME70j21_sram_flashloader.icf SAME70n19_sram_flashloader.icf SAME70n20_sram_flashloader.icf SAME70n21_sram_flashloader.icf SAME70q19_sram_flashloader.icf SAME70q20_sram_flashloader.icf SAME70q21_sram_flashloader.icf
