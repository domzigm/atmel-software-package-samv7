# IAR project internalFlashLoader.ewp, settings and files
configuration same70q21 (ARM, debug)
  General.OGChipSelectEditMenu: ATsame70Q21 Atmel ATsame70Q21
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAME70Q21__; sram
  ICCARM.CCIncludePath2: $PROJ_DIR$; include; $TOOLKIT_DIR$\src\flashloader\framework2; $TOOLKIT_DIR$\inc\Atmel\same70; ..\interface; $TOOLKIT_DIR$\CMSIS\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: internalFlashLoader.srec
  ILINK.IlinkOutputFile: same70q21-flash.out
  ILINK.IlinkIcfFile: mapping\same70q21_sram_flashloader.icf
  ILINK.IlinkProgramEntryLabel: FlashInitEntry
configuration same70q20 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: ATsame70Q20 Atmel ATsame70Q20
  ICCARM.CCDefines: __SAME70Q20__; sram
  ILINK.IlinkOutputFile: same70q20-flash.out
  ILINK.IlinkIcfFile: mapping\same70q20_sram_flashloader.icf
configuration same70q19 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: ATsame70Q19 Atmel ATsame70Q19
  ICCARM.CCDefines: __SAME70Q19__; sram
  ILINK.IlinkOutputFile: same70q19-flash.out
  ILINK.IlinkIcfFile: mapping\same70q19_sram_flashloader.icf
configuration same70n21 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: ATsame70N21 Atmel ATsame70N21
  ICCARM.CCDefines: __SAME70N21__; sram
  ILINK.IlinkOutputFile: same70n21-flash.out
  ILINK.IlinkIcfFile: mapping\same70n21_sram_flashloader.icf
configuration same70n20 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: ATsame70N20 Atmel ATsame70N20
  ICCARM.CCDefines: __SAME70N20__; sram
  ILINK.IlinkOutputFile: same70n20-flash.out
  ILINK.IlinkIcfFile: mapping\same70n20_sram_flashloader.icf
configuration same70n19 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: ATsame70N19 Atmel ATsame70N19
  ICCARM.CCDefines: __SAME70N19__; sram
  ILINK.IlinkOutputFile: same70n19-flash.out
  ILINK.IlinkIcfFile: mapping\same70n19_sram_flashloader.icf
configuration same70j21 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: ATsame70J21 Atmel ATsame70J21
  ICCARM.CCDefines: __SAME70J21__; sram
  ILINK.IlinkOutputFile: same70j21-flash.out
  ILINK.IlinkIcfFile: mapping\same70j21_sram_flashloader.icf
configuration same70j20 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: ATsame70Q20 Atmel ATsame70Q20
  ICCARM.CCDefines: __SAME70J20__; sram
  ILINK.IlinkOutputFile: same70j20-flash.out
  ILINK.IlinkIcfFile: mapping\same70j20_sram_flashloader.icf
configuration same70j19 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: ATsame70J19 Atmel ATsame70J19
  ICCARM.CCDefines: __SAME70J19__; sram
  ILINK.IlinkOutputFile: same70j19-flash.out
  ILINK.IlinkIcfFile: mapping\same70j19_sram_flashloader.icf
  group (top)
    src/: efc.c flashd.c
    include/: efc.h flashd.h
    ./: flash_config.h internalFlashLoader.c
    ../interface/: Interface.c
  group framework
    $EW_DIR$/arm/src/flashloader/framework2/: flash_loader.c flash_loader_asm.s
  group mapping
    mapping/: same70j19_sram_flashloader.icf same70j20_sram_flashloader.icf same70j21_sram_flashloader.icf same70n19_sram_flashloader.icf same70n20_sram_flashloader.icf same70n21_sram_flashloader.icf same70q19_sram_flashloader.icf same70q20_sram_flashloader.icf same70q21_sram_flashloader.icf
