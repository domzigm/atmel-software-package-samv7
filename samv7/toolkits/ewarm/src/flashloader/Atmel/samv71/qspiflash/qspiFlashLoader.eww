<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\qspiFlashLoader.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>qspiFlashLoader</project>
        <configuration>samv71j19</configuration>
      </member>
      <member>
        <project>qspiFlashLoader</project>
        <configuration>samv71j20</configuration>
      </member>
      <member>
        <project>qspiFlashLoader</project>
        <configuration>samv71j21</configuration>
      </member>
      <member>
        <project>qspiFlashLoader</project>
        <configuration>samv71n19</configuration>
      </member>
      <member>
        <project>qspiFlashLoader</project>
        <configuration>samv71n20</configuration>
      </member>
      <member>
        <project>qspiFlashLoader</project>
        <configuration>samv71n21</configuration>
      </member>
      <member>
        <project>qspiFlashLoader</project>
        <configuration>samv71q19</configuration>
      </member>
      <member>
        <project>qspiFlashLoader</project>
        <configuration>samv71q20</configuration>
      </member>
      <member>
        <project>qspiFlashLoader</project>
        <configuration>samv71q21</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


