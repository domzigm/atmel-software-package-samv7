# IAR project qspiFlashLoader.ewp, settings and files
configuration samv71q21 (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMV71Q21 Atmel ATSAMV71Q21
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAMV71Q21__; sram
  ICCARM.CCIncludePath2: $PROJ_DIR$; include; $TOOLKIT_DIR$\src\flashloader\framework2; $TOOLKIT_DIR$\inc\Atmel\samv71; $TOOLKIT_DIR$\CMSIS\include; ..\interface
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: qspiFlashLoader.srec
  ILINK.IlinkOutputFile: samv71q21-qspiflash.out
  ILINK.IlinkIcfFile: mapping\samv71q21_sram_flashloader.icf
  ILINK.IlinkProgramEntryLabel: FlashInitEntry
configuration samv71q20 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: ATSAMV71Q20 Atmel ATSAMV71Q20
  ICCARM.CCDefines: __SAMV71Q20__; sram
  ICCARM.CCIncludePath2: $PROJ_DIR$; include; $TOOLKIT_DIR$\src\flashloader\framework2; $TOOLKIT_DIR$\inc\Atmel\samv71; ..\interface; $TOOLKIT_DIR$\CMSIS\include
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: samv71q20-flash.out
  ILINK.IlinkIcfFile: mapping\samv71q20_sram_flashloader.icf
configuration samv71q19 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: ATSAMV71Q19 Atmel ATSAMV71Q19
  ICCARM.CCDefines: __SAMV71Q19__; sram
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: samv71q19-flash.out
  ILINK.IlinkIcfFile: mapping\samv71q19_sram_flashloader.icf
configuration samv71n21 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: ATSAMV71N21 Atmel ATSAMV71N21
  ICCARM.CCDefines: __SAMV71N21__; sram
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: samv71n21-flash.out
  ILINK.IlinkIcfFile: mapping\samv71n21_sram_flashloader.icf
configuration samv71n20 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: ATSAMV71N20 Atmel ATSAMV71N20
  ICCARM.CCDefines: __SAMV71N20__; sram
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: samv71n20-flash.out
  ILINK.IlinkIcfFile: mapping\samv71n20_sram_flashloader.icf
configuration samv71n19 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: ATSAMV71N19 Atmel ATSAMV71N19
  ICCARM.CCDefines: __SAMV71N19__; sram
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: samv71n19-flash.out
  ILINK.IlinkIcfFile: mapping\samv71n19_sram_flashloader.icf
configuration samv71j21 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: ATSAMV71J21 Atmel ATSAMV71J21
  ICCARM.CCDefines: __SAMV71J21__; sram
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: samv71j21-flash.out
  ILINK.IlinkIcfFile: mapping\samv71j21_sram_flashloader.icf
configuration samv71j20 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: ATSAMV71J20 Atmel ATSAMV71J20
  ICCARM.CCDefines: __SAMV71J20__; sram
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: samv71j20-flash.out
  ILINK.IlinkIcfFile: mapping\samv71j20_sram_flashloader.icf
configuration samv71j19 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: ATSAMV71J19 Atmel ATSAMV71J19
  ICCARM.CCDefines: __SAMV71J19__; sram
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: samv71j19-flash.out
  ILINK.IlinkIcfFile: mapping\samv71j19_sram_flashloader.icf
  group (top)
    include/: board.h pio.h pmc.h qspi.h qspi_dma.h s25fl1.h xdmac.h xdmad.h
    ./: flash_config.h qspiFlashLoader.c
    ../interface/: Interface.c
    src/: pio.c pmc.c qspi.c s25fl1.c
  group framework
    $EW_DIR$/arm/src/flashloader/framework2/: flash_loader.c flash_loader_asm.s
  group mapping
    mapping/: samv71j19_sram_flashloader.icf samv71j20_sram_flashloader.icf samv71j21_sram_flashloader.icf samv71n19_sram_flashloader.icf samv71n20_sram_flashloader.icf samv71n21_sram_flashloader.icf samv71q19_sram_flashloader.icf samv71q20_sram_flashloader.icf samv71q21_sram_flashloader.icf
