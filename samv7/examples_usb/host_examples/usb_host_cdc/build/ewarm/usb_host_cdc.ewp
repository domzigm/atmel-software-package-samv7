# IAR project usb_host_cdc.ewp, settings and files
configuration sram (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMV71Q21 Atmel SAMV71Q21
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD_SAMV71_XULT; __SAMV71Q21__; sram; UHD_NO_SLEEP_MGR; TRACE_LEVEL=4
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ../../; ../../../../../libraries; ../../../../../libraries/libboard; ../../../../../libraries/libboard/include; ../../../../../libraries/libchip; ../../../../../libraries/libchip/include; ../../../../../libraries/libchip/include/samv71; ../../../../../libraries/libchip/include/cmsis/CMSIS/Include; ../../conf; ../../../../../libraries/libusb/host; ../../../../../libraries/libusb/host/core; ../../../../../libraries/libusb/host/hid; ../../../../../libraries/libusb/host/cdc; ../../../../../libraries/libusb; ../../../../../libraries/libusb/include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD_SAMV71_XULT; __SAMV71Q21__; sram; __ASSEMBLY__
  OBJCOPY.OOCOutputFile: sram.bin
  ILINK.IlinkOutputFile: sram.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\libraries\libboard\resources_v71\iar\samv71q21_sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flash (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMV71_XULT; __SAMV71Q21__; flash; UHD_NO_SLEEP_MGR; TRACE_LEVEL=4
  AARM.ADefines: BOARD_SAMV71_XULT; __SAMV71Q21__; flash; __ASSEMBLY__
  OBJCOPY.OOCOutputFile: flash.bin
  ILINK.IlinkOutputFile: flash.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\libraries\libboard\resources_v71\iar\samv71q21_flash.icf
  group (top)
    ../../: main.c ui.c ui.h usart_cdc.c usart_cdc.h
    ../: conf_usb_host.h
  group documentation
    $EW_DIR$/arm/examples/Atmel/: flashloaders.html
    ../../../../../documentation/html/: usb_host_cdc.html
  group libraries/libboard
    ../../../../../libraries/libboard/: board.h
    ../../../../../libraries/libboard/source/: board_lowlevel.c board_memories.c dbg_console.c led.c trace.c
    ../../../../../libraries/libboard/resources_v71/: system_samv71.c
  group libraries/libchip
    ../../../../../libraries/libchip/source/: usart.c usart_dma.c exceptions.c mpu.c pio.c pio_it.c pmc.c supc.c tc.c timetick.c uart.c wdt.c xdma_hardware_interface.c xdmac.c xdmad.c
    ../../../../../libraries/libchip/: chip.h
    ../../../../../libraries/libboard/resources_v71/iar/: startup_samv71.c
  group libraries/libusb
    ../../../../../libraries/libusb/common/core/: USBH_HAL.c
    ../../../../../libraries/libusb/host/core/: USBH.c
    ../../../../../libraries/libusb/host/cdc/: uhi_cdc.c
  group resources
    ../../../../../libraries/libboard/resources_v71/iar/: samv71q21_sram.icf samv71q21_flash.icf
