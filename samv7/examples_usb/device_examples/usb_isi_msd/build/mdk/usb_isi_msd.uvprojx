# Keil uVision project usb_isi_msd.uvprojx, settings and files
target flash (ARM-ADS)
  device: ATSAMV71Q21 Atmel
  pack: Keil.SAM-V_DFP.1.0.0
  cpu: IROM(0x00400000,0x00200000) IRAM(0x20400000,0x00060000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: usb_isi_msd
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: BOARD_SAMV71_XULT __SAMV71Q21__ flash SD_SINGLE_LINE_MODE TRACE_LEVEL=2
  c include: ..\..\;..\..\..\..\..\libraries\libchip;..\..\..\..\..\libraries\libchip\include;..\..\..\..\..\libraries\libchip\include\samv71;..\..\..\..\..\libraries\libchip\include\cmsis\CMSIS\Include;..\..\..\..\..\libraries\libboard;..\..\..\..\..\libraries\libboard\include;..\..\..\..\..\libraries\libusb;..\..\..\..\..\libraries\libusb\include;..\..\..\..\..\libraries\libstoragemedia;..\..\..\..\..\libraries\libstoragemedia\include;..\..\..\..\..\libraries\libstoragemedia\include\sdmmc;..\..\..\..\..\libraries\libfatfs;..\..\..\..\..\libraries\libfatfs\inc;..\..\..\..\..\libraries\libfatfs\src;..\..\..\..\..\libraries\libjpeg;..\..\..\..\..\libraries\libjpeg\include
  memory RVCT4: ROM 0x400000 size 0x200000
  memory RVCT9: RAM 0x20400000 size 0x60000
  scatter file: .\flash.sct
  link misc: --diag_suppress=L6314
  group application
    ../../../../../libraries/libboard/resources_v71/mdk/: workaround.s
    ../../: main.c isi_capture.c USBDDriverDescriptors.c
  group libchip
    ../../../../../libraries/libchip/source/: exceptions.c mpu.c pio.c pio_it.c pmc.c supc.c tc.c timetick.c uart.c wdt.c xdma_hardware_interface.c xdmac.c xdmad.c isi.c uart_dma.c usart.c usart_dma.c twi.c twid.c mcid_dma.c hsmci.c
    ../../../../../libraries/libboard/resources_v71/mdk/: retarget.c startup_sam.c
    ../../../../../libraries/libboard/resources_v71/: system_samv71.c
  group libboard
    ../../../../../libraries/libboard/source/: board_lowlevel.c board_memories.c dbg_console.c led.c trace.c image_sensor_inf.c ov2640_config.c ov2643_config.c ov5640_config.c ov7740_config.c ov9740_config.c ov7670_config.c bmp.c
  group libusb
    ../../../../../libraries/libusb/common/core/: USBD_HAL.c USBDescriptors.c USBRequests.c
    ../../../../../libraries/libusb/device/massstorage/: MSDDStateMachine.c MSDFunction.c MSDIOFifo.c MSDLun.c SBCMethods.c MSDDriver.c
    ../../../../../libraries/libusb/device/core/: USBD.c USBDCallbacks.c USBDDriver.c USBDDriverCallbacks.c
  group libfatfs
    ../../../../../libraries/libfatfs/src/: diskio_samv7x.c fattime_rtc.c ff.c lowlevel.c
    ../../../../../libraries/libfatfs/src/option/: ccsbcs.c
  group libmemory
    ../../../../../libraries/libstoragemedia/source/sdmmc/: sdmmc.c
    ../../../../../libraries/libstoragemedia/source/: Media.c MEDRamDisk.c MEDSdcard.c
  group libjpeg
    ../../../../../libraries/libjpeg/source/: jaricom.c jerror.c jmemmgr.c jmemnobs.c jutils.c jcarith.c jccoefct.c jccolor.c jcdctmgr.c jchuff.c jcinit.c jcmainct.c jcmarker.c jcmaster.c jcprepct.c jcsample.c jdatadst_mem.c jfdctflt.c jfdctfst.c jfdctint.c jdarith.c jdatasrc_mem.c jdcoefct.c jdcolor.c jddctmgr.c jdhuff.c jdinput.c jdmainct.c jdmarker.c jdmaster.c jdmerge.c jdpostct.c jdsample.c jidctflt.c jidctfst.c jidctint.c jquant1.c jquant2.c jcapimin.c jcapistd.c jcomapi.c jcparam.c jctrans.c jdapimin.c jdapistd.c jdtrans.c
    ../../../../../libraries/libjpeg/: libjpeg.c
