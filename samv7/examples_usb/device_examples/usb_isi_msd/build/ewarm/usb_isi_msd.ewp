# IAR project usb_isi_msd.ewp, settings and files
configuration flash (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMV71Q21 Atmel SAMV71Q21
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD_SAMV71_XULT; __SAMV71Q21__; flash; SD_SINGLE_LINE_MODE; TRACE_LEVEL=2
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ../../; ../../../../../libraries; ../../../../../libraries/libboard; ../../../../../libraries/libboard/include; ../../../../../libraries/libchip; ../../../../../libraries/libchip/include; ../../../../../libraries/libchip/include/samv71; ../../../../../libraries/libchip/include/cmsis/CMSIS/Include; ../../../../../libraries/libusb; ../../../../../libraries/libusb/include; ../../../../../libraries/libstoragemedia; ../../../../../libraries/libstoragemedia/include; ../../../../../libraries/libstoragemedia/include/sdmmc; ../../../../../libraries/libfatfs; ../../../../../libraries/libfatfs/inc; ../../../../../libraries/libfatfs/src; ../../../../../libraries/libjpeg; ../../../../../libraries/libjpeg/include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD_SAMV71_XULT; __SAMV71Q21__; flash; __ASSEMBLY__
  OBJCOPY.OOCOutputFile: flash.bin
  ILINK.IlinkOutputFile: flash.out
  ILINK.IlinkIcfFile: config\flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../: main.c isi_capture.c USBDDriverDescriptors.c
  group documentation
    $EW_DIR$/arm/examples/Atmel/: flashloaders.html
    ../../../../../documentation/html/: usb_isi_msd.html
  group libraries/libboard
    ../../../../../libraries/libboard/source/: image_sensor_inf.c ov2640_config.c ov2643_config.c ov5640_config.c ov7740_config.c ov9740_config.c bmp.c board_lowlevel.c board_memories.c dbg_console.c led.c trace.c
    ../../../../../libraries/libboard/: board.h
    ../../../../../libraries/libboard/resources_v71/: system_samv71.c
  group libraries/libchip
    ../../../../../libraries/libchip/source/: isi.c uart_dma.c usart.c usart_dma.c twi.c twid.c mcid_dma.c hsmci.c exceptions.c mpu.c pio.c pio_it.c pmc.c supc.c tc.c timetick.c uart.c wdt.c xdma_hardware_interface.c xdmac.c xdmad.c
    ../../../../../libraries/libchip/: chip.h
    ../../../../../libraries/libboard/resources_v71/iar/: startup_samv71.c
  group libraries/libusb
    ../../../../../libraries/libusb/common/core/: USBD_HAL.c USBDescriptors.c USBRequests.c
    ../../../../../libraries/libusb/device/massstorage/: MSDDStateMachine.c MSDFunction.c MSDIOFifo.c MSDLun.c SBCMethods.c MSDDriver.c
    ../../../../../libraries/libusb/device/core/: USBD.c USBDCallbacks.c USBDDriver.c USBDDriverCallbacks.c
  group libraries/libfatfs
    ../../../../../libraries/libfatfs/: fatfs_config.h
    ../../../../../libraries/libfatfs/src/: diskio_samv7x.c fattime_rtc.c ff.c lowlevel.c
    ../../../../../libraries/libfatfs/src/option/: ccsbcs.c
  group libraries/libmemory
    ../../../../../libraries/libstoragemedia/source/sdmmc/: sdmmc.c
    ../../../../../libraries/libstoragemedia/source/: Media.c MEDRamDisk.c MEDSdcard.c
  group libraries/libjpeg
    ../../../../../libraries/libjpeg/source/: jaricom.c jerror.c jmemmgr.c jmemnobs.c jutils.c jcarith.c jccoefct.c jccolor.c jcdctmgr.c jchuff.c jcinit.c jcmainct.c jcmarker.c jcmaster.c jcprepct.c jcsample.c jdatadst_mem.c jfdctflt.c jfdctfst.c jfdctint.c jdarith.c jdatasrc_mem.c jdcoefct.c jdcolor.c jddctmgr.c jdhuff.c jdinput.c jdmainct.c jdmarker.c jdmaster.c jdmerge.c jdpostct.c jdsample.c jidctflt.c jidctfst.c jidctint.c jquant1.c jquant2.c jcapimin.c jcapistd.c jcomapi.c jcparam.c jctrans.c jdapimin.c jdapistd.c jdtrans.c
    ../../../../../libraries/libjpeg/: libjpeg.c libjpeg.h
  group resources
    config/: flash.icf
