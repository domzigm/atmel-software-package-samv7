# IAR project usb_video.ewp, settings and files
configuration sram (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMV71Q21 Atmel SAMV71Q21
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD_SAMV71_XULT; __SAMV71Q21__; sram; MCK_123MHZ; TRACE_LEVEL=4
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ../../; ../../../../../libraries; ../../../../../libraries/libboard; ../../../../../libraries/libboard/include; ../../../../../libraries/libchip; ../../../../../libraries/libchip/include; ../../../../../libraries/libchip/include/samv71; ../../../../../libraries/libchip/include/cmsis/CMSIS/Include; ../../../../../libraries/libusb; ../../../../../libraries/libusb/include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD_SAMV71_XULT; __SAMV71Q21__; sram; __ASSEMBLY__
  OBJCOPY.OOCOutputFile: sram.bin
  ILINK.IlinkOutputFile: sram.out
  ILINK.IlinkIcfFile: config\sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flash (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMV71_XULT; __SAMV71Q21__; flash; MCK_123MHZ; TRACE_LEVEL=4
  AARM.ADefines: BOARD_SAMV71_XULT; __SAMV71Q21__; flash; __ASSEMBLY__
  OBJCOPY.OOCOutputFile: flash.bin
  ILINK.IlinkOutputFile: flash.out
  ILINK.IlinkIcfFile: config\flash.icf
configuration app (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMV71_XULT; __SAMV71Q21__; app; MCK_123MHZ; TRACE_LEVEL=4
  AARM.ADefines: BOARD_SAMV71_XULT; __SAMV71Q21__; app; __ASSEMBLY__
  OBJCOPY.OOCOutputFile: app.bin
  ILINK.IlinkOutputFile: app.out
  ILINK.IlinkIcfFile: config\app.icf
  group (top)
    ../../: main.c USBDDriverDescriptors.c
  group documentation
    $EW_DIR$/arm/examples/Atmel/: flashloaders.html
    ../../../../../documentation/html/: usb_video.html
  group libraries/libboard
    ../../../../../libraries/libboard/source/: image_sensor_inf.c ov2640_config.c ov2643_config.c ov5640_config.c ov7740_config.c ov9740_config.c board_lowlevel.c board_memories.c dbg_console.c led.c trace.c
    ../../../../../libraries/libboard/: board.h
    ../../../../../libraries/libboard/resources_v71/: system_samv71.c
  group libraries/libchip
    ../../../../../libraries/libchip/source/: twi.c twid.c isi.c exceptions.c mpu.c pio.c pio_it.c pmc.c supc.c tc.c timetick.c uart.c wdt.c xdma_hardware_interface.c xdmac.c xdmad.c
    ../../../../../libraries/libchip/: chip.h
    ../../../../../libraries/libboard/resources_v71/iar/: startup_samv71.c
  group libraries/libusb
    ../../../../../libraries/libusb/common/core/: USBD_HAL.c USBDescriptors.c USBRequests.c
    ../../../../../libraries/libusb/device/core/: USBD.c USBDCallbacks.c USBDDriver.c USBDDriverCallbacks.c
  group resources
    config/: sram.icf flash.icf app.icf
